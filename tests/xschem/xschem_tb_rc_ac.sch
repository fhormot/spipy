** sch_path: tests/xschem/xschem_tb_rc_ac.sch
**.subckt xschem_tb_rc_ac
C1 v_cap 0 1e-12 m=1
R1 v_in v_cap 1e6 m=1
V1 v_in 0 dc 1 ac 1
**.ends
.end
